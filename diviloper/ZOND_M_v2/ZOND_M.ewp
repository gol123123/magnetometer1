# IAR project ZOND_M.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2481 MSP430F2481
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2481.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.IccLang: 1
  group (top)
    ./: main.c
